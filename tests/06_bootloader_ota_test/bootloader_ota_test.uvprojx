# Keil uVision project bootloader_ota_test.uvprojx, settings and files
target bootloader_ota_test (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: bootloader_ota_test +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER,SYSTEM_SUPPORT_OS=0
  c include: ..\..\SYSTEM\sys;..\..\USER;..\..\CORE;..\..\STM32F10x_FWLib\inc;..\..\BSP\IAP;..\..\BSP\STMFLASH;..\..\BSP\DMA;..\..\BSP\CRC32;..\..\BSP\SPI;..\..\BSP\W25QXX;..\..\BSP\GPIO;..\..\Shared;..\common
  asm define: ,SYSTEM_SUPPORT_OS=0
  asm include: as above
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c
    ../../USER/: stm32f10x_it.c system_stm32f10x.c
  group BSP
    ../../BSP/IAP/: iap.c
    ../../BSP/STMFLASH/: stmflash.c
    ../../BSP/DMA/: dma.c
    ../../BSP/CRC32/: crc32.c
    ../../BSP/SPI/: spi.c
    ../../BSP/W25QXX/: w25qxx.c
    ../common/: delay.c
  group SYSTEM
    ../../SYSTEM/sys/: sys.c
  group CORE
    ../../CORE/: core_cm3.c startup_stm32f10x_md.s
  group STM32F10x_FWLib
    ../../STM32F10x_FWLib/src/: misc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_adc.c
